# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\FWlib\inc;..\..\Libraries\FWlib\src;..\..\Libraries\CMSIS;..\..\User;..\..\Periph\LED;..\..\Periph\DELAY;..\..\Periph\LCD;..\..\Periph\ASCII;..\..\Periph\USART;..\..\Periph\FLASH;..\..\Periph\TOUCH;..\..\Periph\OV7670
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c stm32f4xx.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group USER
    ../../User/: main.c stm32f4xx_conf.h stm32f4xx_it.c main.h main_init.c struct.h
  group DOC
    ../../DOC/: readme.txt
  group PERIPH
    ../../Periph/LED/: led.c
    ../../Periph/DELAY/: delay.c
    ../../Periph/LCD/: lcd.c
    ../../Periph/ASCII/: ascii.c
    ../../Periph/USART/: usart.c
    ../../Periph/FLASH/: flash_spi.c
    ../../Periph/TOUCH/: touch.c touch_spi.c
    ../../Periph/OV7670/: ov7725.c sccb.c ov7725_proc.c
software components: CMSIS:CORE 5.0.0
